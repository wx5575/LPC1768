# Keil uVision project UCOS_II_V289.uvproj, settings and files
target UCOS_II_V289 (ARM-ADS)
  device: LPC1768 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: UCOS_II_V289 +hex
  c flags: Optim=1
  c include: .\APP;.\lpc17xx;.\uC-CPU;.\uCOS-II;.\BSP;.\DEV\LCD;.\DEV\KEY;.\Resource;.\Panel;.\Test;.\DEV\AT24CXX;.\DEV\AD;.\DEV\DA
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group lpc17xx
    ./lpc17xx/: core_cm3.c startup_LPC17xx.s system_LPC17xx.c
  group APP
    ./APP/: hello.c main.c TaskCorr.c
  group uCOS-II
    ./uCOS-II/: os_tmr.c os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c
  group uC-CPU
    ./uC-CPU/: os_cpu_a.asm os_cpu_c.c os_dbg.c
  group BSP
    ./BSP/: bsp_gpio.c bsp_timer.c buzzer.c EINT.c uart.c
  group KEY
    ./DEV/KEY/: key.c move.c keyfuntion.c system_parameter.c
  group LCD
    ./DEV/LCD/: lcd.c
  group Resource
    ./Resource/: stringhandle.c datavalue.c delay.c
  group Panel
    ./Panel/: panel.c
  group Test
    ./Test/: test.c uart_test.c
  group AT24CXX
    ./DEV/AT24CXX/: at24cxx.c readandwrite.c resreadandwrite.c
  group AD
    ./DEV/AD/: AD.c
  group DA
    ./DEV/DA/: DA.c
